# Keil uVision project EXTI_KEY_LED.uvprojx, settings and files
target EXTI_KEY_LED (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EXTI_KEY_LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Arm;.\Driver;.\GD32_Hal;.\GD32_Hal\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/: mail.c
  group Driver
    ./Driver/: led_drv.c key_drv.c
  group Arm
    ./Arm/: startup_gd32f30x_hd.s system_gd32f30x.c
  group GD32_Hal
    ./GD32_Hal/Source/: gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c
